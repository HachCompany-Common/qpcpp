# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __FPU_PRESENT
  ICCARM.CCDiagSuppress: Pe540
  ICCARM.IExtraOptions: --enable-restrict
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\include; ..\..\..\..\..\ports\freertos; ..\..\..\..\..\3rd_party\ek-tm4c123gxl; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\FreeRTOS-Kernel\include; ..\..\..\..\..\3rd_party\FreeRTOS-Kernel\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..\..\ports\freertos\arm-cm\iar
  OBJCOPY.OOCOutputFile: dpp.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkIcfFile: dpp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; __FPU_PRESENT
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: Q_SPY; __FPU_PRESENT
  group Application
    ../: bsp.cpp bsp.h dpp.h FreeRTOSConfig.h main.cpp philo.cpp table.cpp
    ../../../../../include/: qstamp.cpp
  group ek-tm4c123gxl
    ../../../../../3rd_party/ek-tm4c123gxl/: gpio.h rom.h sysctl.h system_TM4C123GH6PM.c system_TM4C123GH6PM.h TM4C123GH6PM.h
    ../../../../../3rd_party/ek-tm4c123gxl/iar/: startup_TM4C123GH6PM.s
  group FreeRTOS
    ../../../../../3rd_party/FreeRTOS-Kernel/: list.c queue.c tasks.c
    ../../../../../3rd_party/FreeRTOS-Kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
  group QP_port
    ../../../../../ports/freertos/: qep_port.h qf_port.cpp qf_port.h qs_port.h
  group QS
    ../../../../../src/qs/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_rx.cpp qutest.cpp
